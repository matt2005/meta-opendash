LIC_FILES_CHKSUM = "file://../git/CMakeLists.txt;md5=2a71911262da0e390c161bb44d29f979"
SRC_URI = "git://github.com/Opendsh/aasdk.git;protocol=https;branch=develop"
SRCREV = "develop"
