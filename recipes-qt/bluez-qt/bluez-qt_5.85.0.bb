# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git@github.com:KDE/bluez-qt.git;protocol=https;branch=master"
SRCREV = "ba48b662f7d5cf59f8f839e19642e95714a1ef6b"

