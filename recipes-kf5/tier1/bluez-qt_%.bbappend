SRC_URI = "git://github.com/KDE/bluez-qt.git;protocol=https;branch=master"
SRCREV = "ba48b662f7d5cf59f8f839e19642e95714a1ef6b"

# this indicates the folder to run do_compile from.
S="${WORKDIR}/git"