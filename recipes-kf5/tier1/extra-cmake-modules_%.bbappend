SRC_URI = "git://github.com/KDE/extra-cmake-modules.git;protocol=https;branch=master"
SRCREV = "95d1808924d9ecdf3037939ba78950fe20ee1396"

# this indicates the folder to run do_compile from.
S="${WORKDIR}/git"